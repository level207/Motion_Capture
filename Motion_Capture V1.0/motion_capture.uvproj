# Keil uVision project motion_capture.uvproj, settings and files
target 目标 1 (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: motion_capture +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 mc_common_define.h mc_init_8051.c mc_init_8051.h mc_main.c mc_sensor.c mc_sensor.h mc_algorithm.c
